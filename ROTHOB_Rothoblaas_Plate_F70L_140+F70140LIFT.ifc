Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 0f422ecc-4fbc-4c83-93c2-4fdc5110cd5e, NumberOfSaves: 11], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Emplazamiento por defecto]
File name: IFC Export 2022.ifc
Time: 2026-03-03T10:07:46
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 25, 13, 9643; RefLongitude: -3, -42, -20, -772056; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey: Level:Nivel 1, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0_Rothoblaas; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 0_Rothoblaas; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Nivel 1; Type: Nivel 1; Type Id: 927
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Trazo punto; Line Weight: 1; Symbol: Extremo de nivel; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Nivel 1
Other(Type) - Category: Levels; Family Name: Level

# IfcMember: Structural Connections : ROTHOB_Rothoblaas_Plate_F70LIFT : F70140LIFT_160x160x22mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_CarbonSteel_ZincPlated
Type - General - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_F70LIFT; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/pillar-bases/f70#F70; Revision: n/a; UniClass2015Code: Pr_20_76_64_54; UniClass2015Title: Metal post bases; UniClass2015Version: Products v1.33; Version: 3
Type - Constraints - Default Elevation: 1219.2 mm; ModelNumberCode: 140
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_ZincPlated
Type - Dimensions - Height_H: 22 mm; Lenght_P: 160 mm; Thickness_s: 2 mm; Width_B: 160 mm
Type - Identity Data - OmniClass Number: 23.13.23.11.19.13; Type Name: F70140LIFT_160x160x22mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: n/a; CECode: ETA-10/0422; CETitle: n/a; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: “T” shaped post base; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_F70LIFT; Features: Support of timber columns and post bases as bearing elements; Finish: Zinc plated; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Carbon steel; MinWeight: 0.6kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: F70140LIFT; ModelReference: n/a; Name: Plate; NominalHeight: 22 mm; NominalLength: 160 mm; NominalWidth: 160 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 160x160x22mm; Size_Imperial: 6 1/4x6 1/4x7/8 in; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate
Pset_MemberCommon - Reference: F70140LIFT_160x160x22mm
Pset_QuantityTakeOff - Reference: F70140LIFT_160x160x22mm
BaseQuantities - NetVolume: 0.0000726087 m3; NetSurfaceArea: 0.0748179 m2
Constraints - Elevation from Level: 0 mm; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas; Host: Level : 0_Rothoblaas
Phasing - Phase Created: Nueva construcción
Dimensions - Volume: 0.0000726087 m3
Other - Family: ROTHOB_Rothoblaas_Plate_F70LIFT; Family and Type: ROTHOB_Rothoblaas_Plate_F70LIFT: F70140LIFT_160x160x22mm; Type: F70140LIFT_160x160x22mm; Type Id: 231533

# IfcMember: Structural Connections : ROTHOB_Rothoblaas_Plate_F70L_140 : F70140L_140x140x308mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: <Unnamed>, ROTHOB_Rothoblaas_CarbonSteel_HotDipGalvanising
Type - Visibility - HasHole_F70100L: no; HasHole_F70140L: yes
Type - General - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_F70L; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/pillar-bases/f70#F70; Revision: 001; UniClass2015Code: Pr_20_76_64_54; UniClass2015Title: Metal post bases; UniClass2015Version: Products v1.33; Version: 003
Type - Constraints - Default Elevation: 1219.2 mm; ModelNumberCode: 140
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_HotDipGalvanising
Type - Dimensions - BaseHoleDiameter: 11.5 mm; BaseHoleDistance: 20 mm; BottomPlateThickness_s1: 8 mm; Height_H: 308 mm; KnifePlateThickness_s: 8 mm; Lenght_P: 140 mm; Width_B: 140 mm
Type - Identity Data - OmniClass Number: 23.13.23.11.19.13; Type Name: F70140L_140x140x308mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: n/a; CECode: ETA-10/0422; CETitle: n/a; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: “T” shaped post base; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_F70L_140; Features: Support of timber columns and post bases as bearing elements; Finish: Hot dip galvanising; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Carbon steel; MinWeight: 3.79 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: F70140L; ModelReference: n/a; Name: Plate; NominalHeight: 308 mm; NominalLength: 140 mm; NominalWidth: 140 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 140x140x308 mm; Size_Imperial: 5 1/2x5 1/2x12 1/8 in; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate
Pset_MemberCommon - Reference: F70140L_140x140x308mm
Pset_QuantityTakeOff - Reference: F70140L_140x140x308mm
BaseQuantities - Length: 8 mm; CrossSectionArea: 0.0196 m2; OuterSurfaceArea: 0.00448 m2; GrossSurfaceArea: 0.04368 m2; GrossVolume: 0.0001568 m3; NetVolume: 0.000483105 m3; NetSurfaceArea: 0.135414 m2
Constraints - Elevation from Level: 0 mm; Host: Level : 0_Rothoblaas; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas
Phasing - Phase Created: Nueva construcción
Dimensions - Volume: 0.000483105 m3
Other - Family: ROTHOB_Rothoblaas_Plate_F70L_140; Family and Type: ROTHOB_Rothoblaas_Plate_F70L_140: F70140L_140x140x308mm; Type: F70140L_140x140x308mm; Type Id: 222887
