Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 5dd0fbdc-f484-4ce0-ac8c-ac4ab979fe37, NumberOfSaves: 12], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Emplazamiento por defecto]
File name: ROTHOB_Rothoblaas_Plate_F70L_100+F70100LIFT.ifc
Time: 2026-03-03T10:41:35
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nombre de proyecto; Phase: Estado de proyecto

# IfcSite, Default
RefLatitude: 40, 25, 13, 9643; RefLongitude: -3, -42, -20, -772056; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Propietario; Project Address: Introduzca dirección aquí; Project Issue Date: Fecha de emisión; Project Name: Nombre de proyecto; Project Number: 0001; Project Status: Estado de proyecto

# IfcBuildingStorey: Level:Nivel 1, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0_Rothoblaas; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 0_Rothoblaas; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Nivel 1; Type: Nivel 1; Type Id: 927
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Trazo punto; Line Weight: 1; Symbol: Extremo de nivel; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Nivel 1
Other(Type) - Category: Levels; Family Name: Level

# IfcMember: Structural Connections : ROTHOB_Rothoblaas_Plate_F70LIFT : F70100LIFT_120x120x20mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_CarbonSteel_ZincPlated
Type - General - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_F70LIFT; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/pillar-bases/f70#F70; Revision: n/a; UniClass2015Code: Pr_20_76_64_54; UniClass2015Title: Metal post bases; UniClass2015Version: Products v1.33; Version: 3
Type - Constraints - Default Elevation: 1219.2 mm; ModelNumberCode: 100
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_ZincPlated
Type - Dimensions - Height_H: 20 mm; Lenght_P: 120 mm; Thickness_s: 2 mm; Width_B: 120 mm
Type - Identity Data - OmniClass Number: 23.13.23.11.19.13; Type Name: F70100LIFT_120x120x20mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: n/a; CECode: ETA-10/0422; CETitle: n/a; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: “T” shaped post base; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_F70LIFT; Features: Support of timber columns and post bases as bearing elements; Finish: Zinc plated; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Carbon steel; MinWeight: 0.35kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: F70100LIFT; ModelReference: n/a; Name: Plate; NominalHeight: 20 mm; NominalLength: 120 mm; NominalWidth: 120 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 120x120x20mm; Size_Imperial: 4 3/4x4 3/4x13/16 in; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate
Pset_MemberCommon - Reference: F70100LIFT_120x120x20mm
Pset_QuantityTakeOff - Reference: F70100LIFT_120x120x20mm
BaseQuantities - NetVolume: 0.0000428997 m3; NetSurfaceArea: 0.0445969 m2
Constraints - Elevation from Level: 0 mm; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas; Host: Level : 0_Rothoblaas
Phasing - Phase Created: Nueva construcción
Dimensions - Volume: 0.0000428997 m3
Other - Family: ROTHOB_Rothoblaas_Plate_F70LIFT; Family and Type: ROTHOB_Rothoblaas_Plate_F70LIFT: F70100LIFT_120x120x20mm; Type: F70100LIFT_120x120x20mm; Type Id: 231531

# IfcMember: Structural Connections : ROTHOB_Rothoblaas_Plate_F70L_100 : F70100L_100x100x206mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: <Unnamed>, ROTHOB_Rothoblaas_CarbonSteel_HotDipGalvanising
Type - Visibility - HasHole_F70100L: yes; HasHole_F70140L: no
Type - General - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_F70L; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/pillar-bases/f70#F70; Revision: n/a; UniClass2015Code: Pr_20_76_64_54; UniClass2015Title: Metal post bases; UniClass2015Version: Products v1.33; Version: 3
Type - Constraints - Default Elevation: 1219.2 mm; ModelNumberCode: 100
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_HotDipGalvanising
Type - Dimensions - BaseHoleDiameter: 9 mm; BaseHoleDistance: 15 mm; BottomPlateThickness_s1: 6 mm; Height_H: 206 mm; KnifePlateThickness_s: 6 mm; Lenght_P: 100 mm; Width_B: 100 mm
Type - Identity Data - OmniClass Number: 23.13.23.11.19.13; Type Name: F70100L_100x100x206mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: n/a; CECode: ETA-10/0422; CETitle: n/a; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: “T” shaped post base; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_F70L_100; Features: Support of timber columns and post bases as bearing elements; Finish: Hot dip galvanising; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Carbon steel; MinWeight: 1.421 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: F70100L; ModelReference: n/a; Name: Plate; NominalHeight: 206 mm; NominalLength: 100 mm; NominalWidth: 100 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 100x100x206 mm; Size_Imperial: 4x4x8 1/8 in; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate
Pset_MemberCommon - Reference: F70100L_100x100x206mm
Pset_QuantityTakeOff - Reference: F70100L_100x100x206mm
BaseQuantities - Length: 6 mm; CrossSectionArea: 0.00995002 m2; OuterSurfaceArea: 0.00232972 m2; GrossSurfaceArea: 0.0222297 m2; GrossVolume: 0.0000597001 m3; NetVolume: 0.000174987 m3; NetSurfaceArea: 0.0659182 m2
Constraints - Elevation from Level: 0 mm; Host: Level : 0_Rothoblaas; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas
Phasing - Phase Created: Nueva construcción
Dimensions - Volume: 0.000174987 m3
Other - Family: ROTHOB_Rothoblaas_Plate_F70L_100; Family and Type: ROTHOB_Rothoblaas_Plate_F70L_100: F70100L_100x100x206mm; Type: F70100L_100x100x206mm; Type Id: 227575
