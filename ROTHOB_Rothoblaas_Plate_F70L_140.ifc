Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: a2ba49b9-cced-4a46-a842-046720296d34, NumberOfSaves: 70], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Plate_F70L_140.ifc
Time: 2025-11-10T12:19:33
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcMember: Collegamenti strutturali : ROTHOB_Rothoblaas_Plate_F70L_140 : F70140L_140x140x308mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: <Unnamed>, ROTHOB_Rothoblaas_CarbonSteel_HotDipGalvanising
Type - Visibilità - HasHole_F70100L: no; HasHole_F70140L: yes
Type - Generale - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_F70L; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/pillar-bases/f70#F70; Revision: 001; UniClass2015Code: Pr_20_76_64_54; UniClass2015Title: Metal post bases; UniClass2015Version: Products v1.33; Version: 003
Type - Vincoli - ModelNumberCode: 140; Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_HotDipGalvanising
Type - Quote - BaseHoleDiameter: 11.5 mm; BaseHoleDistance: 20 mm; BottomPlateThickness_s1: 8 mm; Height_H: 308 mm; KnifePlateThickness_s: 8 mm; Lenght_P: 140 mm; Width_B: 140 mm
Type - Dati identità - Nome del tipo: F70140L_140x140x308mm; Numero OmniClass: 23.13.23.11.19.13
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: n/a; Category: Pr_20_76_64_54 - Metal post bases; CECode: ETA-10/0422; CETitle: n/a; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: “T” shaped post base; DurationUnit: Years; ExpectedLife: 50; Features: Support of timber columns and post bases as bearing elements; Finish: Hot dip galvanising; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Carbon steel; MinWeight: 3.79 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: F70140L; ModelReference: n/a; Name: Plate; Nome famiglia: ROTHOB_Rothoblaas_Plate_F70L_140; NominalHeight: 308 mm; NominalLength: 140 mm; NominalWidth: 140 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 140x140x308 mm; Size_Imperial: 5 1/2x5 1/2x12 1/8 in; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate; Category: Pr_20_76_64_54 - Metal post bases
Pset_MemberCommon - Reference: F70140L_140x140x308mm
Pset_QuantityTakeOff - Reference: F70140L_140x140x308mm
BaseQuantities - Length: 8 mm; CrossSectionArea: 0.0196 m2; OuterSurfaceArea: 0.00448 m2; GrossSurfaceArea: 0.04368 m2; GrossVolume: 0.0001568 m3; NetVolume: 0.000483105 m3; NetSurfaceArea: 0.135414 m2
Vincoli - Host: Livello : 0_Rothoblaas; Livello: 0_Rothoblaas; Livello abaco: 0_Rothoblaas; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Volume: 0.000483105 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Plate_F70L_140; Famiglia e tipo: ROTHOB_Rothoblaas_Plate_F70L_140: F70140L_140x140x308mm; ID tipo: 813429; Tipo: F70140L_140x140x308mm
