Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 8b155428-cf09-4fd6-a978-f4ed261ea46c, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Planimetria di default], ExchangeRequirement [Structural]
File name: 0001
Time: 2024-06-05T14:39:58+01:00
Written by: ODA SDAI 22.12
Made in: 23.1.40.56 - Exporter 23.2.5.0 - Alternate UI 23.2.5.0

# IfcProject, 0001
LongName: Nome del progetto; Phase: Stato del progetto

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 cm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Immettere l'indirizzo; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: 0001; Stato del progetto: Stato del progetto

# IfcBuildingStorey: Livello:Estremità 8 mm (2)
Quote - Altezza di calcolo: 0 cm
Dati identità - Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: 333; Tipo: Estremità 8 mm
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Centro; Simbolo: M_Estremità del livello - Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Estremità 8 mm
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Name | LongName = Nome | Elevation (cm) = Quota altimetrica (cm)
Livello 1 | Livello 1 | 0
Livello 2 | Livello 2 | 300

# IfcBuildingElementProxy: ROTHOB_Rothoblaas_Plate_F70_180_220:F70180_120x180x400mm, ROTHOB_Rothoblaas_Plate_F70_180_220:F70180_120x180x400mm:379886
In: Livello 2
Type - Material: <Unnamed>, ROTHOB_Rothoblaas_CarbonSteel_HotDipGalvanising
Type - Generale - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_F70; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/pillar-bases/f70#F70; Revision: n/a; UniClass2015Code: Pr_20_76_64_54; UniClass2015Title: Metal post bases; UniClass2015Version: Products v1.33; Version: 3
Type - Vincoli - ModelNumberCode: 180; Prospetto di default: 121.92 cm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_HotDipGalvanising
Type - Quote - BaseHoleDiameter: 1.8 cm; BaseHoleDistance: 2.2 cm; BottomPlateThickness_s1: 1.2 cm; Height_H: 40 cm; KnifePlateThickness_s: 0.6 cm; Length_P: 18 cm; Width_B: 12 cm
Type - Dati identità - Nome del tipo: F70180_120x180x400mm; Numero OmniClass: 23.13.23.11.19.13; Titolo OmniClass: Wood Connectors
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: n/a; Category: Pr_20_76_64_54 - Metal post bases; CECode: ETA-10/0422; CETitle: n/a; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: “T” shaped post base; DurationUnit: Years; ExpectedLife: 50; Features: Support of timber columns and post bases as bearing elements; Finish: Hot dip galvanising; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Carbon steel; MinWeight: 7.2 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: F70180; ModelReference: n/a; Name: Plate; Nome famiglia: ROTHOB_Rothoblaas_Plate_F70_180_220; NominalHeight: 40 cm; NominalLength: 18 cm; NominalWidth: 12 cm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 120x180x400 mm; Size_Imperial: 4 3/4x7 1/8x15 3/4 in; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Plate; Category: Pr_20_76_64_54 - Metal post bases
Type - Pset_ProvisionForVoid - Shape: Three-dimensional
Pset_BuildingElementProxyCommon - Reference: F70180_120x180x400mm; sets with these values: 2
Vincoli - Host: <non associato>; Livello: Livello 2; Livello abaco: Livello 2; Quota altimetrica da livello: -300 cm
Fasi - Fase di creazione: Nuova costruzione
Quote - Volume: 0.000664226 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Plate_F70_180_220; Famiglia e tipo: ROTHOB_Rothoblaas_Plate_F70_180_220: F70180_120x180x400mm; ID tipo: 390907; Tipo: F70180_120x180x400mm
